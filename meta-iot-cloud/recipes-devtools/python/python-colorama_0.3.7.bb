inherit setuptools
require python-colorama.inc
